
FILESEXTRAPATHS_append := ":${THISDIR}/wayland"
SRC_URI += "file://0001-Change-socket-mode-add-rw-for-group.patch"
SRC_URI += "file://0001-add-roundtrip-race-condtion.patch"
